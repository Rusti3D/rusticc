require rusticc-firmware-swap.inc
RUSTICC_FW = "cosmos-${RUSTICC_PRINTER}-toolhead.bin"
