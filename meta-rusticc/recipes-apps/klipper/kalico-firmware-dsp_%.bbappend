# (config.mainboard: the same DSP firmware for both printers)
require rusticc-firmware-swap.inc
RUSTICC_FW = "cosmos-cc1-dsp.elf"
RUSTICC_FW_OUT = "klipper.elf"
