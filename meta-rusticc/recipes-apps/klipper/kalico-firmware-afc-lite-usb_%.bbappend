require rusticc-firmware-swap.inc
RUSTICC_FW = "cosmos-afc-lite-usb.bin"
