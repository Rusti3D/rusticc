require rusticc-firmware-swap.inc
RUSTICC_FW = "cosmos-${RUSTICC_PRINTER}-bed.bin"
