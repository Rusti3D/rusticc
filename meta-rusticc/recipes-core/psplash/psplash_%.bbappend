# Rusticc's boot splash (rusticc_1.png, made by
# branding/make_assets.py); COSMOS's bar and colours
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES = " \
    file://rusticc_1.png;outsuffix=default \
"
