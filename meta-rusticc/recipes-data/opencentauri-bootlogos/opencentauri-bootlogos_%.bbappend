# Rusticc's boot logo (files/<machine>/bootlogo.bmp, made by
# branding/make_assets.py); magic.bin stays COSMOS's
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
